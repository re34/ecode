# IAR project ecode_nucleo_l073.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L073RZ ST STM32L073RZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L073xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\common; ..\..\..\..\drivers; ..\..\..\..\platform; ..\..\..; ..\..; ..\..\BSP; ..\..\CMSIS; ..\..\common; ..; ..\TOOLCHAIN_IAR; ..\..\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\user; ..\..\..\..\library\OS\FreeRTOS\include; ..\..\..\..\library\OS\FreeRTOS\portable\IAR\ARM_CM0; ..\..\..\..\library\OS; ..\..\..\..\user\applications
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ..\..\..\..\common
  OBJCOPY.OOCOutputFile: ecode_nucleo_l073.bin
  ILINK.IlinkOutputFile: ecode_nucleo_l073.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    ../../../../common/: link_list.c
  group common
    ../../../../common/: crc16.c crc8.c fifo.c print_log.c
  group drivers
    ../../../../drivers/: ecode_tick.c led.c mcu.c uart.c
  group library/OS/FreeRTOS
    ../../../../library/OS/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group library/OS/FreeRTOS/portable
    ../../../../library/OS/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../library/OS/FreeRTOS/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group platform
    ../../../../platform/: ecode.c ecode_cli.c ecode_cli_errno.c ecode_message_parsing.c ecode_message_read_line.c ecode_rtos.c platform_cli_handles.c platform_driver.c pwm.c serial.c stdio_ex.c timer.c timestamp.c version.c
  group targets/TARGET_STM32L0/BSP
    ../../BSP/: bsp_base_timer.c bsp_clock.c bsp_mcu.c bsp_pin.c bsp_pwm.c bsp_tick.c bsp_uart.c
  group targets/TARGET_STM32L0/common
    ../../common/: stm32l0xx_hal_msp.c stm32l0xx_it.c system_stm32l0xx.c
  group targets/TARGET_STM32L0/NUCLEO_L073
    ../TOOLCHAIN_IAR/: startup_stm32l073xx.s
  group targets/TARGET_STM32L0/STM32L0xx_HAL_Driver
    ../../STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c stm32l0xx_ll_adc.c stm32l0xx_ll_comp.c stm32l0xx_ll_crc.c stm32l0xx_ll_crs.c stm32l0xx_ll_dac.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_i2c.c stm32l0xx_ll_lptim.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rng.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c
  group user
    ../../../../user/: main.c
  group user/applications
    ../../../../user/applications/: display.c
