# IAR project NUCLEO_F303.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303RE ST STM32F303RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F303xE; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\common; ..\..\..\..\drivers; ..\..\..\..\platform; ..\..\..; ..\..; ..\..\BSP; ..\..\CMSIS; ..\..\common; ..; ..\TOOLCHAIN_IAR; ..\..\STM32F3xx_HAL_Driver\Inc; ..\..\..\..\user; ..\..\..\..\library\OS\FreeRTOS\include; ..\..\..\..\library\OS\FreeRTOS\portable\IAR\ARM_CM4F; ..\..\..\..\library\OS; ..\..\..\..\user\applications
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: NUCLEO_F303.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group common
    ../../../../common/: crc16.c crc8.c fifo.c link_list.c print_log.c
  group drivers
    ../../../../drivers/: ecode_tick.c led.c mcu.c uart.c
  group library/OS/FreeRTOS
    ../../../../library/OS/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group library/OS/FreeRTOS/portable
    ../../../../library/OS/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../library/OS/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group platform
    ../../../../platform/: ecode.c ecode_cli.c ecode_cli_errno.c ecode_message_parsing.c ecode_message_read_line.c ecode_rtos.c platform_cli_handles.c platform_driver.c pwm.c serial.c sim_iic.c stdio_ex.c timer.c timestamp.c version.c
  group targets/TARGET_STM32F3/BSP
    ../../BSP/: bsp_base_timer.c bsp_clock.c bsp_mcu.c bsp_pin.c bsp_pwm.c bsp_tick.c bsp_uart.c
  group targets/TARGET_STM32F3/CMSIS
    ../../CMSIS/: core_cm4.h
  group targets/TARGET_STM32F3/common
    ../../common/: stm32f3xx_hal_msp.c stm32f3xx_it.c system_stm32f3xx.c
  group targets/TARGET_STM32F3/NUCLEO_F303
    ../TOOLCHAIN_IAR/: startup_stm32f303xe.s
  group targets/TARGET_STM32F3/STM32F3xx_HAL_Driver
    ../../STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_cec.c stm32f3xx_hal_comp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_crc.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2s.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_irda.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_nand.c stm32f3xx_hal_nor.c stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_pccard.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_smartcard.c stm32f3xx_hal_smartcard_ex.c stm32f3xx_hal_smbus.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_sram.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_tsc.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c stm32f3xx_hal_wwdg.c stm32f3xx_ll_adc.c stm32f3xx_ll_comp.c stm32f3xx_ll_crc.c stm32f3xx_ll_dac.c stm32f3xx_ll_dma.c stm32f3xx_ll_exti.c stm32f3xx_ll_fmc.c stm32f3xx_ll_gpio.c stm32f3xx_ll_hrtim.c stm32f3xx_ll_i2c.c stm32f3xx_ll_opamp.c stm32f3xx_ll_pwr.c stm32f3xx_ll_rcc.c stm32f3xx_ll_rtc.c stm32f3xx_ll_spi.c stm32f3xx_ll_tim.c stm32f3xx_ll_usart.c stm32f3xx_ll_utils.c
  group user
    ../../../../user/: main.c
  group user/applications
    ../../../../user/applications/: display.c
