# IAR project ecode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303RE ST STM32F303RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F303xE
  ICCARM.CCIncludePath2: ..\..\..\library\FreeRTOS\include; ..\..\..\library\FreeRTOS\portable\IAR\ARM_CM4F; ..\..\..\platform; ..\applications; ..\drivers; ..\CMSIS; ..\STM32F3xx_HAL_Driver\Inc; ..\..\..\utils; ..\..\..\library\lwip\include; ..\..\..\library\lwip\include\netif
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\drivers
  OBJCOPY.OOCOutputFile: ecode.bin
  ILINK.IlinkOutputFile: ecode.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group library/FreeRTOS
    ../../../library/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group library/FreeRTOS/portable
    ../../../library/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../library/FreeRTOS/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s portmacro.h
  group library/lwip/api
    ../../../library/lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group library/lwip/core
    ../../../library/lwip/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group library/lwip/core/ipv4
    ../../../library/lwip/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group library/lwip/netif
    ../../../library/lwip/netif/: ethernet.c lowpan6.c slipif.c
  group platform
    ../../../platform/: ascii12.c ascii16.c cli_errno.c cli_errno.h cli_message_parsing.c cli_message_parsing.h cli_message_read_line.c cli_message_read_line.h config.h delay.c delay.h ecode.c ecode.h ecode_cli.c ecode_cli.h ecode_rtos.c ecode_rtos.h ethernetif.c includes.h oled.c platform_cli_handles.c platform_cli_handles.h platform_driver.c platform_driver.h print_log.c print_log.h pwm.c pwm.h serial.c serial.h stdio_ex.c stdio_ex.h ticks.c timer.c timer.h timer_event.c timer_event.h timestamp.c timestamp.h types.h version.c version.h
  group user/applications
    ../applications/: applications.c bt_cli_handle.c bt_spp.c measure_dist.c motor.c smart_car.c smart_car_handle.c startup.c
  group user/drivers
    ../drivers/: board.c eth.c FreeRTOSConfig.h hcsr04.c lan8720.c pwm2.c pwm3.c startup_stm32f303xe.s stm32f3xx_hal_msp.c stm32f3xx_it.c stm_pin.c system_stm32f3xx.c uart.c uart2.c user_oled.c
  group user/STM32F3xx_HAL_Driver
    ../STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_cec.c stm32f3xx_hal_comp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_crc.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2s.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_irda.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_nand.c stm32f3xx_hal_nor.c stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_pccard.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_smartcard.c stm32f3xx_hal_smartcard_ex.c stm32f3xx_hal_smbus.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_sram.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_tsc.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c stm32f3xx_hal_wwdg.c stm32f3xx_ll_adc.c stm32f3xx_ll_comp.c stm32f3xx_ll_crc.c stm32f3xx_ll_dac.c stm32f3xx_ll_dma.c stm32f3xx_ll_exti.c stm32f3xx_ll_fmc.c stm32f3xx_ll_gpio.c stm32f3xx_ll_hrtim.c stm32f3xx_ll_i2c.c stm32f3xx_ll_opamp.c stm32f3xx_ll_pwr.c stm32f3xx_ll_rcc.c stm32f3xx_ll_rtc.c stm32f3xx_ll_spi.c stm32f3xx_ll_tim.c stm32f3xx_ll_usart.c stm32f3xx_ll_utils.c
  group utils
    ../../../utils/: crc16.c crc16.h crc8.c crc8.h fifo.c fifo.h link_list.c link_list.h
