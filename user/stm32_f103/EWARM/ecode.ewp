# IAR project ecode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ..\..\..\common; ..\..\..\drivers; ..\..\..\library\FreeRTOS\include; ..\..\..\library\FreeRTOS\portable\IAR\ARM_CM3; ..\..\..\library\lua; ..\..\..\library\lwip\include; ..\..\..\library\lwip\include\ipv4; ..\..\..\library\lwip\arch; ..\..\..\module; ..\..\..\platform; ..\applications; ..\CMSIS; ..\drivers; ..\STM32F1xx_HAL_Driver\Inc; ..\..\..\utils; ..\..\..\library\lwip
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\library\FreeRTOS\portable\IAR\ARM_CM3; ..\drivers
  ILINK.IlinkOutputFile: ecode.out
  ILINK.IlinkIcfFile: ecode.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group drivers/chip
    ../../../drivers/chip/: eeprom.c mpu6050.c
  group drivers/eth
    ../../../drivers/eth/: ethernetif.c
  group drivers/iic
    ../../../drivers/iic/: iic.c iic_bit.c
  group drivers/oled
    ../../../drivers/oled/: ascii12.c ascii16.c oled.c
  group drivers/pin
    ../../../drivers/pin/: pin.c
  group drivers/serial
    ../../../drivers/serial/: serial.c
  group drivers/spi
    ../../../drivers/spi/: spi.c spi_bit.c
  group drivers/timer
    ../../../drivers/timer/: hwtimer.c pwm.c timer.c
  group library/FreeRTOS
    ../../../library/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group library/FreeRTOS/portable
    ../../../library/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../library/FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s
  group library/lua
    ../../../library/lua/: lapi.c lapi.h lauxlib.c lauxlib.h lbaselib.c lbitlib.c lcode.c lcode.h lcorolib.c lctype.c lctype.h ldblib.c ldebug.c ldebug.h ldo.c ldo.h ldump.c lfunc.c lfunc.h lgc.c lgc.h linit.c liolib.c llex.c llex.h llimits.h lmathlib.c lmem.c lmem.h loadlib.c lobject.c lobject.h lopcodes.c lopcodes.h loslib.c lparser.c lparser.h lprefix.h lstate.c lstate.h lstring.c lstring.h lstrlib.c ltable.c ltable.h ltablib.c ltm.c ltm.h lua.h lua.hpp luaconf.h lualib.h lundump.c lundump.h lutf8lib.c lvm.c lvm.h lzio.c lzio.h
  group library/lwip/api
    ../../../library/lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group library/lwip/arch
    ../../../library/lwip/arch/: sys_arch.c
  group library/lwip/core
    ../../../library/lwip/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group library/lwip/core/ipv4
    ../../../library/lwip/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group library/lwip/netif
    ../../../library/lwip/netif/: etharp.c slipif.c
  group module/cli
    ../../../module/cli/: cli.c cli_errno.c command.c
  group platform
    ../../../platform/: assert.c device.c etime.c object.c print_log.c rtos.c stdio_ex.c version.c
  group user/applications
    ../applications/: applications.c command_handle.c command_service.c led_task.c startup.c
  group user/drivers
    ../drivers/: board.c startup_stm32f103xe.s stm32f1xx_hal_msp.c stm32f1xx_it.c stm_pin.c system_stm32f1xx.c uart.c
  group user/STM32F1xx_HAL_Driver
    ../STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group utils
    ../../../utils/: crc16.c crc8.c fifo.c link_list.c pid.c
