# IAR project ecode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L073RZ ST STM32L073RZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L073xx
  ICCARM.CCIncludePath2: ..\..\..\library\FreeRTOS\include; ..\..\..\library\FreeRTOS\portable\IAR\ARM_CM0; ..\..\..\platform; ..\applications; ..\drivers; ..\CMSIS; ..\STM32L0xx_HAL_Driver\Inc; ..\..\..\utils
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\drivers
  OBJCOPY.OOCOutputFile: ecode.bin
  ILINK.IlinkOutputFile: ecode.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group library/FreeRTOS
    ../../../library/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group library/FreeRTOS/portable
    ../../../library/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../library/FreeRTOS/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group platform
    ../../../platform/: ascii12.c ascii16.c cli_errno.c cli_message_parsing.c cli_message_read_line.c delay.c device.c ecode.c ecode_assert.c ecode_cli.c ecode_rtos.c iic.c object.c oled.c pid.c pin.c platform_cli_handles.c print_log.c pwm.c serial.c sim_iic.c stdio_ex.c ticks.c timeout.c timer.c timer_event.c timestamp.c version.c
  group user/applications
    ../applications/: applications.c startup.c
  group user/drivers
    ../drivers/: board.c startup_stm32l073xx.s stm32l0xx_hal_msp.c stm32l0xx_it.c stm_pin.c system_stm32l0xx.c uart.c
  group user/STM32L0xx_HAL_Driver
    ../STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c stm32l0xx_ll_adc.c stm32l0xx_ll_comp.c stm32l0xx_ll_crc.c stm32l0xx_ll_crs.c stm32l0xx_ll_dac.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_i2c.c stm32l0xx_ll_lptim.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rng.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_utils.c
  group utils
    ../../../utils/: crc16.c crc16.h crc8.c crc8.h fifo.c fifo.h link_list.c link_list.h
