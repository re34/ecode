# IAR project ecode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F767ZI ST STM32F767ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F767xx
  ICCARM.CCIncludePath2: ..\..\..\library\FreeRTOS\include; ..\..\..\library\FreeRTOS\portable\IAR\ARM_CM7\r0p1; ..\..\..\platform; ..\applications; ..\drivers; ..\CMSIS; ..\STM32F7xx_HAL_Driver\Inc; ..\..\..\utils; ..\..\..\library\lwip\include; ..\..\..\library\lwip\include\netif; ..\..\..\library\lwip; ..\..\..\module; ..\..\..\drivers; ..\..\..\module\cli; ..\..\..\drivers\serial; ..\..\..\common; ..\..\..\drivers\iic
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\drivers
  OBJCOPY.OOCOutputFile: ecode.bin
  ILINK.IlinkOutputFile: ecode.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group common
    ../../../common/: ecode.h
  group drivers/eth
    ../../../drivers/eth/: ethernetif.c
  group drivers/iic
    ../../../drivers/iic/: iic.c iic_bit.c
  group drivers/oled
    ../../../drivers/oled/: ascii12.c ascii16.c oled.c
  group drivers/pin
    ../../../drivers/pin/: pin.c
  group drivers/serial
    ../../../drivers/serial/: serial.c
  group drivers/spi
    ../../../drivers/spi/: spi.c spi_bit.c
  group drivers/timer
    ../../../drivers/timer/: pwm.c timer.c
  group library/FreeRTOS
    ../../../library/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group library/FreeRTOS/portable
    ../../../library/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../library/FreeRTOS/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s portmacro.h
  group library/lwip/api
    ../../../library/lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group library/lwip/arch
    ../../../library/lwip/arch/: sys_arch.c
  group library/lwip/core
    ../../../library/lwip/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group library/lwip/core/ipv4
    ../../../library/lwip/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c inet.c ip4.c ip4_addr.c ip4_frag.c
  group library/lwip/netif
    ../../../library/lwip/netif/: ethernet.c lowpan6.c slipif.c
  group module/cli
    ../../../module/cli/: cli.c cli_errno.c command.c
  group platform
    ../../../platform/: assert.c device.c object.c print_log.c rtos.c time.c version.c
  group user/applications
    ../applications/: applications.c command_handle.c command_service.c led_task.c startup.c
  group user/drivers
    ../drivers/: board.c eth.c FreeRTOSConfig.h lan8742.c startup_stm32f767xx.s stm32f7xx_it.c stm_pin.c system_stm32f7xx.c uart.c
  group user/STM32F7xx_HAL_Driver
    ../STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_mmc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_smbus.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_adc.c stm32f7xx_ll_crc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_exti.c stm32f7xx_ll_fmc.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_lptim.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_rtc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_usb.c stm32f7xx_ll_utils.c
  group utils
    ../../../utils/: crc16.c crc16.h crc8.c crc8.h fifo.c fifo.h link_list.c link_list.h pid.c
